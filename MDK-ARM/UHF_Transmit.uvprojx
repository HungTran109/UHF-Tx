# Keil uVision project UHF_Transmit.uvprojx, settings and files
target UHF_Transmit (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32L010C6Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.1
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: UHF +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,STM32L010x6,USE_HAL_DRIVER
  c include: ../Core/Inc;../source/app_btn;../source/app_led;../source/SEGGER_RTT_V698b;../source;../source/app_debug;../source/SEGGER_RTT_V698b/RTT;../Drivers/STM32L0xx_HAL_Driver/Inc;../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../Drivers/CMSIS/Include;../MDK-ARM;../source/app_cli;../source/lwrb
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32l010x6.s
  group Application/User/Core
    ../source/: internal_flash.c
    ./: app_main.c sys_ctx.c sys_ctx.h internal_flash.h
    ../Core/Src/: main.c gpio.c adc.c i2c.c iwdg.c usart.c stm32l0xx_it.c stm32l0xx_hal_msp.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l0xx.c
  group app_led
    ../source/app_led/: app_led.c app_led.h
  group app_uhf
    ../source/: app_uhf.h app_uhf.c
  group app_btn
    ../source/app_btn/: app_btn.c app_btn.h
  group app_debug
    ../source/app_debug/: app_debug.c app_debug.h
    ../source/SEGGER_RTT_V698b/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_ll_gpio.c stm32l0xx_ll_adc.c stm32l0xx_ll_dma.c stm32l0xx_hal.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_exti.c stm32l0xx_ll_rcc.c stm32l0xx_ll_utils.c stm32l0xx_ll_exti.c stm32l0xx_ll_i2c.c stm32l0xx_hal_iwdg.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_ll_usart.c
  group kt046x_driver
    ../source/: KT_WirelessMicTxdrv.c KT_WirelessMicTxdrv.h
  group app_cli
    ../source/app_cli/: app_cli.c app_shell.c
  group lwrb
    ../source/lwrb/: lwrb.c lwrb.h
software components: CMSIS:CORE 4.3.0
